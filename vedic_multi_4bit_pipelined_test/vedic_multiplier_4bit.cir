* C:\FOSSEE\eSim\library\SubcircuitLibrary\vedic_multiplier_4bit\vedic_multiplier_4bit.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 10/08/22 00:54:21

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ p3 p2 p1 p0 q3 q2 q1 q0 r3 r2 r1 r0 s3 s2 s1 s0 partial_product_generator
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ PORT
U4  p1l p0l Net-_U1-Pad10_ Net-_U1-Pad9_ dac_bridge_2
U2  q3l q2l q1l q0l r3l r2l r1l r0l Net-_U2-Pad9_ Net-_U2-Pad10_ Net-_U2-Pad11_ Net-_U2-Pad12_ Net-_U2-Pad13_ ksa_4bit
U3  Net-_U10-Pad2_ Net-_U10-Pad2_ p3l p2l Net-_U2-Pad10_ Net-_U2-Pad11_ Net-_U2-Pad12_ Net-_U2-Pad13_ Net-_U3-Pad9_ Net-_U3-Pad10_ Net-_U3-Pad11_ Net-_U3-Pad12_ Net-_U3-Pad13_ ksa_4bit
U6  Net-_U3-Pad12_ Net-_U3-Pad13_ Net-_U1-Pad12_ Net-_U1-Pad11_ dac_bridge_2
U5  Net-_U5-Pad1_ Net-_U5-Pad2_ Net-_U3-Pad10_ Net-_U3-Pad11_ s3l s2l s1l s0l Net-_U5-Pad9_ Net-_U5-Pad10_ Net-_U5-Pad11_ Net-_U5-Pad12_ Net-_U5-Pad13_ ksa_4bit
X2  Net-_U8-Pad3_ Net-_U8-Pad4_ Net-_U9-Pad2_ Net-_U9-Pad1_ HA_kalyan
U7  Net-_U5-Pad9_ Net-_U5-Pad10_ Net-_U5-Pad11_ Net-_U5-Pad12_ Net-_U5-Pad13_ Net-_U1-Pad17_ Net-_U1-Pad16_ Net-_U1-Pad15_ Net-_U1-Pad14_ Net-_U1-Pad13_ dac_bridge_5
U8  Net-_U2-Pad9_ Net-_U3-Pad9_ Net-_U8-Pad3_ Net-_U8-Pad4_ dac_bridge_2
U9  Net-_U9-Pad1_ Net-_U9-Pad2_ Net-_U5-Pad2_ Net-_U5-Pad1_ adc_bridge_2
U10  GND Net-_U10-Pad2_ adc_bridge_1
U11  p3 p2 p1 p0 q3 q2 q1 q0 r3 r2 r1 r0 s3 s2 s1 s0 Net-_U11-Pad17_ p3l p2l p1l p0l q3l q2l q1l q0l r3l r2l r1l r0l s3l s2l s1l s0l dff_16
U12  Net-_U1-Pad18_ Net-_U11-Pad17_ adc_bridge_1

.end
